# Keil uVision project CAN_Node.uvproj, settings and files
target Simulator (ARM-ADS)
  device: LPC2378 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40007FFF) IRAM2(0x7FE00000-0x7FE037FF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: CAN_Ex1
  c flags: Optim=4
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  memory RVCT10: RAM 0x7fe00000 size 0x3800
  group Source Files
    ./: RTX_CAN.c CAN_node.c CAN_Hw.c Serial.c CAN_manju.c
  group Configuration
    ./: LPC2300.s RTX_Config.c
  group Documentation
    ./: Abstract.txt
target LPC2300 Flash (ARM-ADS)
  device: LPC2378 NXP (founded by Philips)
  cpu: as above
  output: CAN_Ex1
  c flags: Optim=4
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  memory RVCT10: RAM 0x7fe00000 size 0x3800
